# Keil uVision project BLE_p2pServer.uvprojx, settings and files
target BLE_p2pServer (6240000::V6.24::ARMCLANG)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.2.0.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000004-0x2002FC03) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: BLE_p2pServer +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STM32WBXX_NUCLEO,USE_HAL_DRIVER,STM32WB55xx
  c misc: -Wno-format
  c include: ../Core/Inc;../STM32_WPAN/App;..\STM32WBxx_HAL_Driver\Inc;..\STM32_WPAN;..\STM32_WPAN\ble_thread;..\STM32_WPAN\ble_thread\tl;..\STM32_WPAN\ble_thread\shci;..\STM32_WPAN\utilities;..\Utilities\lpm\tiny_lpm;..\Utilities\sequencer;..\STM32_WPAN\ble;..\STM32_WPAN\ble\core\template;..\STM32_WPAN\ble\core;..\CMSIS\Device\ST\STM32WBxx\Include;..\CMSIS\Include;..\P-NUCLEO-WB55.Nucleo;..\STM32_WPAN\ble\svc\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: .\stm32wb55xx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c app_debug.c app_entry.c stm32_lpm_if.c hw_timerserver.c hw_uart.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c p2p_server_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_iwdg.c stm32wbxx_hal_lptim.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_tsc.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_rng.c
  group Middlewares/STM32_WPAN
    ../STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../STM32_WPAN/ble_thread/shci/: shci.c
    ../STM32_WPAN/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c
    ../STM32_WPAN/utilities/: otp.c stm_list.c stm_queue.c
    ../STM32_WPAN/ble/svc/Src/: svc_ctl.c p2p_stm.c
    ../STM32_WPAN/ble/core/template/: osal.c
  group Utilities
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/sequencer/: stm32_seq.c dbg_trace.c
software components: CMSIS:CORE 5.2.0
